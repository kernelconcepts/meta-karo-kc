# fake hw random generator on i.mx8
# note: reduces random number quality and therefore security

FILESEXTRAPATHS_prepend := "${THISDIR}/files/${MACHINE}:"
