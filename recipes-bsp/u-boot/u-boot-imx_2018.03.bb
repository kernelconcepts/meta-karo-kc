require u-boot-imx-common_2018.03.inc
require u-boot-imx_2018.03.inc
